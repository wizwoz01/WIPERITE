# Keil uVision project WIPERITE.uvprojx, settings and files
target WIPERITE-TM4C123 (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WIPERITE-TM4C123
  AfterMake: fromelf --bin --output .\rvmdk\cc31000_starter.bin .\rvmdk\cc31000_starter.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_TM4C123GH6PM _POSIX_SOURCE UART_BUFFERED TARGET_IS_TM4C123_RB1
  c include: ..;..\;..\..\..\..;..\cc3100;..\cc3100\platform\ek-tm4c123gxl;..\cc3100\simplelink\include;..\cc3100\simplelink\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: cc31000_starter.sct
  link misc: --entry Reset_Handler
  group Source
    ../cc3100/platform/ek-tm4c123gxl/: board.c spi.c
    ./: LED.c startup_rvmdk.S ST7735.c UART0.c GPIO.c main.c motor.c PWM.c SysTick.c video.c I2C.c writing_arm.c servo_demo.c PCA9685.c util.c
    ../cc3100/simplelink/source/: device.c driver.c flowcont.c fs.c netapp.c netcfg.c nonos.c socket.c spawn.c wlan.c
    ../utils/: ustdlib.c uartstdio.c
    ../driverlib/: uart.c
  group Libraries
    ../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
software components: CMSIS:CORE 5.6.0
